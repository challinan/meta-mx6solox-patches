IMAGE_INSTALL_append += " demo-master pmd-hamp misc-utils"

